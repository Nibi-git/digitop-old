# IAR project digitop.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\lnk0t.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.SCRStackSize: 15
  ICCAVR.CCDefines: NDEBUG
  postbuild: avrdude -p t26 -P avrdoper -c stk500v2 -B 5 -U flash:w:Release\Exe\$PROJ_FNAME$.hex:i -U hfuse:w:0x12:m -U lfuse:w:0xe4:m
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgtiny26.xcl
  XLINK.XExtraOptions: -y(CODE)
  group (top)
    ./: main.c
